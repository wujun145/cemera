# IAR project cube_video_test1.ewp, settings and files
configuration cube_video_test1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F429xx
  ICCARM.CCIncludePath2: ..\Inc; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\..\Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ..\..\Middlewares/ST/STM32_USB_Host_Library/Class/VIDEO/Inc; ..\..\Drivers/CMSIS/Device/ST/STM32F4xx/Include; ..\..\Drivers/CMSIS/Include; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Drivers\CMSIS\Include; ..\..\jpeg_lib; ..\..\Drivers\CMSIS\Source\Templates\iar
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cube_video_test1.srec
  ILINK.IlinkOutputFile: cube_video_test1.out
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Source/Templates/iar/: startup_stm32f40xx.s
  group Application/jpeg_lib
    ../../jpeg_lib/: integer.h mjpeg_dht.h tjpgd.c tjpgd.h
  group Application/User
    ../Src/: fonts.c main.c mjpeg_decoding.c stm32f429_lcd.c stm32f429_sdram.c stm32f4xx_hal_msp.c stm32f4xx_it.c usb_host.c usbh_conf.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sdram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_ll_usb.c
  group Middlewares/USB_Host_Library
    ../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../Middlewares/ST/STM32_USB_Host_Library/Class/VIDEO/Src/: usbh_video.c usbh_video_desc_parsing.c usbh_video_stream_parsing.c
