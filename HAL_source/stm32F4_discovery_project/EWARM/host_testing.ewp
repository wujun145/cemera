# IAR project host_testing.ewp, settings and files
configuration host_testing (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx
  ICCARM.CCIncludePath2: ../Inc; ../../Drivers/STM32F4xx_HAL_Driver/Inc; ../../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../../Middlewares/ST/STM32_USB_Host_Library/Class/VIDEO/Inc; ../../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../Drivers/CMSIS/Include; ..\..\Drivers\CMSIS\Source\Templates\iar; ..\..\Bsp\fsmc_lcd; ..\..\Bsp\delay; ..\..\jpeg_lib; ..\..\stm32F429_project\Inc; ..\..\Bsp\mySram; ..\..\Bsp\SerialCom; ..\..\Bsp\flash; ..\..\Bsp\Touch
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: host_testing.out
  ILINK.IlinkIcfFile: stm32f407xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../../Drivers/CMSIS/Source/Templates/iar/: startup_stm32f40xx.s
  group Application/jpeg_lib
    ../../jpeg_lib/: integer.h mjpeg_decoding.c mjpeg_dht.h tjpgd.c tjpgd.h
  group Application/mySram
    ../../Bsp/mySram/: sram.c
  group Application/Serial
    ../../Bsp/SerialCom/: serial.c
  group Application/User
    ../Src/: button.c main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usb_host.c usbh_conf.c
    ../../Bsp/delay/: delay.c
    ../../Bsp/fsmc_lcd/: my_lcd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_usb.c
  group Middlewares/USB_Host_Library
    ../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../Middlewares/ST/STM32_USB_Host_Library/Class/VIDEO/Src/: usbh_video.c usbh_video_desc_parsing.c usbh_video_stream_parsing.c
  group ReadMe
    ../: readme.txt
