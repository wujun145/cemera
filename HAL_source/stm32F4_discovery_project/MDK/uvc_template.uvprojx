# Keil uVision project uvc_template.uvprojx, settings and files
target template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: uvc_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: STM32F407xx,USER_HAL_DRIVER
  c include: ..\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\Middlewares\ST\STM32_USB_Host_Library\Class\VIDEO\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\jpeg_lib;..\..\Bsp\delay;..\..\Bsp\mySram;..\..\Bsp\SerialCom;..\..\stm32F429_project\Inc;..\..\Bsp\Touch;..\..\Bsp\flash;..\..\Bsp\dma;..\..\Bsp\lcd;..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Src/: system_stm32f4xx.c
    ../../Drivers/CMSIS/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c usb_host.c usbh_conf.c
    ../../Bsp/lcd/: bsp_ili9341_lcd.c
  group Bsp
    ../../Bsp/mySram/: sram.c
    ../../Bsp/SerialCom/: serial.c
    ../../Bsp/delay/: delay.c
    ../../Bsp/flash/: bsp_flash.c
    ../../Bsp/lcd/: fonts.c
  group Drivers
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_usb.c
  group Middlewares
    ../../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../../Middlewares/ST/STM32_USB_Host_Library/Class/VIDEO/Src/: usbh_video.c usbh_video_desc_parsing.c usbh_video_stream_parsing.c
  group jpeg_lib
    ../../jpeg_lib/: mjpeg_decoding.c tjpgd.c
  group ReadMe
    ../: readme.txt
